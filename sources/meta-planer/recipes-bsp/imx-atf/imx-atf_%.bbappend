FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Patch-ATF-for-M33-firmware.patch \
            file://0002-Enable-M33.patch \
            "
